# Keil uVision project FlyControl.uvprojx, settings and files
target flycontrol (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 24L01 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\User;..\Code;..\Systream\delay;..\Systream\sys;..\Systream\usart;..\libraries\inc;..\FlyControl\applications;..\FlyControl\arith;..\FlyControl\devices;..\FlyControl\drivers;..\FlyControl\common
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Code
    ../Code/: core_cm3.c startup_stm32f10x_hd.s
  group Libaires
    ../libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group arith
    ../FlyControl/arith/: Algorithm_ahrs.c Fc_Seedestimated.c mymath.c filter.c
  group devices
    ../FlyControl/devices/: device_adc.c device_iic.c device_spi.c device_uart.c device_timer.c device_pwm_out.c device_bluetooth.c device_mpc2520.c device_nrf24l01.c device_mpu6050.c device_led.c device_flash.c device_flow.c
  group drivers
    ../FlyControl/drivers/: driver_mpu6050.c driver_voltage.c
  group applications
    ../FlyControl/applications/: Fc_init.c Fc_control.c Fc_data_transfer.c Fc_scheduler.c Fc_systream_time.c Fc_parameter.c Fc_revice.c
